# Keil uVision project I2S_InternalCODEC_DMA5_DEVBoard.uvproj, settings and files
target I2S_InternalCODEC_DMA5_DEVBoard (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: I2S_InternalCODEC_DMA5_DEVBoard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM4,__FPU_PRESENT=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\\NUC505Series\Include;..\..\..\..\Library\StdDriver\inc
  scatter file: .\scatter.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2s.c retarget.c sys.c uart.c gpio.c i2c.c
    ../: DPSLib.lib
    ../../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Source
    ../: main.c nuc505_isr.c indices.c
