# IAR project superwire.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC122 series Nuvoton NUC122 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\lib\src\; ..\lib\inc\; ..\src\; ..\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: superwire.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\lib\Smpl_DrvGPIO.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group inc
    ../inc/: 1761_IC_1.h 1761_IC_1_REG.h DataType.h function.h io_define.h
  group lib
    ../lib/src/: core_cm0.c DrvFMC.c DrvGPIO.c DrvSYS.c DrvTIMER.c system_NUC122.c
    ../lib/inc/: core_cm0.h DrvFMC.h DrvGPIO.h DrvSYS.h DrvTimer.h ModuleID.h NUC122.h SysInfra.h system_NUC122.h
    ../lib/: startup_NUC122.s
  group src
    ../src/: 1761.c function.c main.c
